# Keil uVision project breeze_nRF51822.uvprojx, settings and files
target nrf51422_xxac (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: nRF51422_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.11.1
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: nrf51422_xxac +hex
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: BLE_STACK_SUPPORT_REQD NRF51422 BOARD_PCA10028 NRF_SD_BLE_API_VERSION=2 S130 NRF51 SOFTDEVICE_PRESENT SWI_DISABLE0
  c include: ..\User;..\Components;..\Components\ble\ble_advertising;..\Components\ble\ble_dtm;..\Components\ble\ble_racp;..\Components\ble\ble_services\ble_ancs_c;..\Components\ble\ble_services\ble_ans_c;..\Components\ble\ble_services\ble_bas;..\Components\ble\ble_services\ble_bas_c;..\Components\ble\ble_services\ble_cscs;..\Components\ble\ble_services\ble_cts_c;..\Components\ble\ble_services\ble_dfu;..\Components\ble\ble_services\ble_dis;..\Components\ble\ble_services\ble_gls;..\Components\ble\ble_services\ble_hids;..\Components\ble\ble_services\ble_hrs;..\Components\ble\ble_services\ble_hrs_c;..\Components\ble\ble_services\ble_hts;..\Components\ble\ble_services\ble_ias;..\Components\ble\ble_services\ble_ias_c;..\Components\ble\ble_services\ble_lbs;..\Components\ble\ble_services\ble_lbs_c;..\Components\ble\ble_services\ble_lls;..\Components\ble\ble_services\ble_nus;..\Components\ble\ble_services\ble_nus_c;..\Components\ble\ble_services\ble_rscs;..\Components\ble\ble_services\ble_rscs_c;..\Components\ble\ble_services\ble_tps;..\Components\ble\common;..\Components\ble\nrf_ble_qwr;..\Components\ble\peer_manager;..\Components\boards;..\Components\drivers_nrf\adc;..\Components\drivers_nrf\clock;..\Components\drivers_nrf\common;..\Components\drivers_nrf\comp;..\Components\drivers_nrf\delay;..\Components\drivers_nrf\gpiote;..\Components\drivers_nrf\hal;..\Components\drivers_nrf\i2s;..\Components\drivers_nrf\lpcomp;..\Components\drivers_nrf\pdm;..\Components\drivers_nrf\power;..\Components\drivers_nrf\ppi;..\Components\drivers_nrf\pwm;..\Components\drivers_nrf\qdec;..\Components\drivers_nrf\rng;..\Components\drivers_nrf\rtc;..\Components\drivers_nrf\saadc;..\Components\drivers_nrf\spi_master;..\Components\drivers_nrf\spi_slave;..\Components\drivers_nrf\swi;..\Components\drivers_nrf\timer;..\Components\drivers_nrf\twi_master;..\Components\drivers_nrf\twis_slave;..\Components\drivers_nrf\uart;..\Components\drivers_nrf\usbd;..\Components\drivers_nrf\wdt;..\Components\libraries\bsp;..\Components\libraries\button;..\Components\libraries\crc16;..\Components\libraries\crc32;..\Components\libraries\csense;..\Components\libraries\csense_drv;..\Components\libraries\experimental_section_vars;..\Components\libraries\fds;..\Components\libraries\fifo;..\Components\libraries\fstorage;..\Components\libraries\gpiote;..\Components\libraries\hardfault;..\Components\libraries\hci;..\Components\libraries\led_softblink;..\Components\libraries\log;..\Components\libraries\log\src;..\Components\libraries\low_power_pwm;..\Components\libraries\mem_manager;..\Components\libraries\pwm;..\Components\libraries\queue;..\Components\libraries\scheduler;..\Components\libraries\slip;..\Components\libraries\timer;..\Components\libraries\twi;..\Components\libraries\uart;..\Components\libraries\usbd;..\Components\libraries\usbd\class\audio;..\Components\libraries\usbd\class\cdc;..\Components\libraries\usbd\class\cdc\acm;..\Components\libraries\usbd\class\hid;..\Components\libraries\usbd\class\hid\generic;..\Components\libraries\usbd\class\hid\kbd;..\Components\libraries\usbd\class\hid\mouse;..\Components\libraries\usbd\class\msc;..\Components\libraries\usbd\config;..\Components\libraries\util;..\Components\softdevice\common\softdevice_handler;..\Components\softdevice\s130\headers;..\Components\softdevice\s130\headers\nrf51;..\Components\toolchain;..\Segger_RTT
  asm define: as above
  asm misc: --cpreproc_opts=-DBLE_STACK_SUPPORT_REQD,-DNRF51422,-DBOARD_PCA10028,-DNRF_SD_BLE_API_VERSION=2,-DS130,-DNRF51,-DSOFTDEVICE_PRESENT,-DSWI_DISABLE0
  asm include: ..\..\..\config\ble_app_uart_pca10028_s130;..\..\..\config;..\..\..\..\..\..\components;..\..\..\..\..\..\components\ble\ble_advertising;..\..\..\..\..\..\components\ble\ble_dtm;..\..\..\..\..\..\components\ble\ble_racp;..\..\..\..\..\..\components\ble\ble_services\ble_ancs_c;..\..\..\..\..\..\components\ble\ble_services\ble_ans_c;..\..\..\..\..\..\components\ble\ble_services\ble_bas;..\..\..\..\..\..\components\ble\ble_services\ble_bas_c;..\..\..\..\..\..\components\ble\ble_services\ble_cscs;..\..\..\..\..\..\components\ble\ble_services\ble_cts_c;..\..\..\..\..\..\components\ble\ble_services\ble_dfu;..\..\..\..\..\..\components\ble\ble_services\ble_dis;..\..\..\..\..\..\components\ble\ble_services\ble_gls;..\..\..\..\..\..\components\ble\ble_services\ble_hids;..\..\..\..\..\..\components\ble\ble_services\ble_hrs;..\..\..\..\..\..\components\ble\ble_services\ble_hrs_c;..\..\..\..\..\..\components\ble\ble_services\ble_hts;..\..\..\..\..\..\components\ble\ble_services\ble_ias;..\..\..\..\..\..\components\ble\ble_services\ble_ias_c;..\..\..\..\..\..\components\ble\ble_services\ble_lbs;..\..\..\..\..\..\components\ble\ble_services\ble_lbs_c;..\..\..\..\..\..\components\ble\ble_services\ble_lls;..\..\..\..\..\..\components\ble\ble_services\ble_nus;..\..\..\..\..\..\components\ble\ble_services\ble_nus_c;..\..\..\..\..\..\components\ble\ble_services\ble_rscs;..\..\..\..\..\..\components\ble\ble_services\ble_rscs_c;..\..\..\..\..\..\components\ble\ble_services\ble_tps;..\..\..\..\..\..\components\ble\common;..\..\..\..\..\..\components\ble\nrf_ble_qwr;..\..\..\..\..\..\components\ble\peer_manager;..\..\..\..\..\..\components\boards;..\..\..\..\..\..\components\drivers_nrf\adc;..\..\..\..\..\..\components\drivers_nrf\clock;..\..\..\..\..\..\components\drivers_nrf\common;..\..\..\..\..\..\components\drivers_nrf\comp;..\..\..\..\..\..\components\drivers_nrf\delay;..\..\..\..\..\..\components\drivers_nrf\gpiote;..\..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\..\components\drivers_nrf\i2s;..\..\..\..\..\..\components\drivers_nrf\lpcomp;..\..\..\..\..\..\components\drivers_nrf\pdm;..\..\..\..\..\..\components\drivers_nrf\power;..\..\..\..\..\..\components\drivers_nrf\ppi;..\..\..\..\..\..\components\drivers_nrf\pwm;..\..\..\..\..\..\components\drivers_nrf\qdec;..\..\..\..\..\..\components\drivers_nrf\rng;..\..\..\..\..\..\components\drivers_nrf\rtc;..\..\..\..\..\..\components\drivers_nrf\saadc;..\..\..\..\..\..\components\drivers_nrf\spi_master;..\..\..\..\..\..\components\drivers_nrf\spi_slave;..\..\..\..\..\..\components\drivers_nrf\swi;..\..\..\..\..\..\components\drivers_nrf\timer;..\..\..\..\..\..\components\drivers_nrf\twi_master;..\..\..\..\..\..\components\drivers_nrf\twis_slave;..\..\..\..\..\..\components\drivers_nrf\uart;..\..\..\..\..\..\components\drivers_nrf\usbd;..\..\..\..\..\..\components\drivers_nrf\wdt;..\..\..\..\..\..\components\libraries\bsp;..\..\..\..\..\..\components\libraries\button;..\..\..\..\..\..\components\libraries\crc16;..\..\..\..\..\..\components\libraries\crc32;..\..\..\..\..\..\components\libraries\csense;..\..\..\..\..\..\components\libraries\csense_drv;..\..\..\..\..\..\components\libraries\experimental_section_vars;..\..\..\..\..\..\components\libraries\fds;..\..\..\..\..\..\components\libraries\fifo;..\..\..\..\..\..\components\libraries\fstorage;..\..\..\..\..\..\components\libraries\gpiote;..\..\..\..\..\..\components\libraries\hardfault;..\..\..\..\..\..\components\libraries\hci;..\..\..\..\..\..\components\libraries\led_softblink;..\..\..\..\..\..\components\libraries\log;..\..\..\..\..\..\components\libraries\log\src;..\..\..\..\..\..\components\libraries\low_power_pwm;..\..\..\..\..\..\components\libraries\mem_manager;..\..\..\..\..\..\components\libraries\pwm;..\..\..\..\..\..\components\libraries\queue;..\..\..\..\..\..\components\libraries\scheduler;..\..\..\..\..\..\components\libraries\slip;..\..\..\..\..\..\components\libraries\timer;..\..\..\..\..\..\components\libraries\twi;..\..\..\..\..\..\components\libraries\uart;..\..\..\..\..\..\components\libraries\usbd;..\..\..\..\..\..\components\libraries\usbd\class\audio;..\..\..\..\..\..\components\libraries\usbd\class\cdc;..\..\..\..\..\..\components\libraries\usbd\class\cdc\acm;..\..\..\..\..\..\components\libraries\usbd\class\hid;..\..\..\..\..\..\components\libraries\usbd\class\hid\generic;..\..\..\..\..\..\components\libraries\usbd\class\hid\kbd;..\..\..\..\..\..\components\libraries\usbd\class\hid\mouse;..\..\..\..\..\..\components\libraries\usbd\class\msc;..\..\..\..\..\..\components\libraries\usbd\config;..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\components\softdevice\common\softdevice_handler;..\..\..\..\..\..\components\softdevice\s130\headers;..\..\..\..\..\..\components\softdevice\s130\headers\nrf51;..\..\..\..\..\..\components\toolchain;..\..\..\..\..\..\external\segger_rtt;..\config
  library: MicroLIB
  memory RVCT4: ROM 0x1b000 size 0x25000
  memory RVCT9: RAM 0x20001fe8 size 0x6018
  group Application
    ../User/: main.c sdk_config.h
  group Board Definition
    ../Components/boards/: boards.c
  group Board Support
    ../Components/libraries/bsp/: bsp.c bsp_nfc.c bsp_btn_ble.c
  group nRF_BLE
    ../Components/ble/common/: ble_advdata.c ble_srv_common.c ble_conn_params.c
    ../Components/ble/ble_advertising/: ble_advertising.c
  group nRF_BLE_Services
    ../Components/ble/ble_services/ble_nus/: ble_nus.c
  group nRF_Drivers
    ../Components/drivers_nrf/adc/: nrf_drv_adc.c
    ../Components/drivers_nrf/ppi/: nrf_drv_ppi.c
    ../Components/drivers_nrf/uart/: nrf_drv_uart.c
    ../Components/drivers_nrf/timer/: nrf_drv_timer.c
    ../Components/drivers_nrf/clock/: nrf_drv_clock.c
    ../Components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../Components/drivers_nrf/common/: nrf_drv_common.c
  group nRF_Libraries
    ../Components/libraries/fifo/: app_fifo.c
    ../Components/libraries/util/: app_error.c app_error_weak.c app_util_platform.c nrf_assert.c sdk_errors.c
    ../Components/libraries/timer/: app_timer.c
    ../Components/libraries/button/: app_button.c
    ../Components/libraries/uart/: app_uart_fifo.c retarget.c
    ../Components/libraries/fstorage/: fstorage.c
    ../Components/libraries/hardfault/: hardfault_implementation.c
  group nRF_Log
    ../Components/libraries/log/src/: nrf_log_frontend.c nrf_log_backend_serial.c
  group nRF_Segger_RTT
    ../Segger_RTT/: RTT_Syscalls_KEIL.c SEGGER_RTT.c SEGGER_RTT_printf.c
  group nRF_SoftDevice
    ../Components/softdevice/common/softdevice_handler/: softdevice_handler.c
target flash_s130_nrf51_2.0.1_softdevice (ARM-ADS)
  device: nRF51422_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.11.1
  cpu: as above
  output: s130_nrf51_2.0.1_softdevice.hex +hex
  c flags: Optim=4 OneElfS=1 uC99=1
  c include: ..\..\..\config\ble_app_uart_pca10028_s130;..\..\..\config;..\config
  asm misc: --cpreproc_opts=
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x1b000 size 0x25000
  memory RVCT9: RAM 0x20001fe8 size 0x6018
software components: CMSIS:CORE 4.3.0, Device:Startup 8.11.1
