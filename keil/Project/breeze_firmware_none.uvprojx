# Keil uVision project breeze_firmware_none.uvprojx, settings and files
target breeze_firmware_none (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103TB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: breeze_firmware_none +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: ..\Libraries\CMSIS;..\Libraries\FWLib\inc;..\User;..\Drivers\Driver_IO;..\Drivers\Driver_IIC;..\Drivers\Driver_Timer;..\Drivers\Driver_NVIC;..\Drivers\Driver_Clock;..\Drivers\Driver_Flash;..\Drivers\Driver_Delay;..\Drivers\Driver_USART;..\Drivers\Driver_EEPROM;..\Modules\Module_LED;..\Modules\Module_Motor;..\Modules\Module_Battery;..\Modules\Module_MS5611;..\Modules\Module_MPU6050;..\Modules\Module_CommLink;..\Modules\Module_HMC5883L;..\Algorithm\Algorithm_IMU;..\Algorithm\Algorithm_Filter;..\Algorithm\Algorithm_Flight;..\Algorithm\Algorithm_Control;..\Algorithm\Algorithm_Altitude
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup
    ../Libraries/CMSIS/startup/: startup_stm32f10x_md.s
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group FWLib
    ../Libraries/FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group User
    ../User/: main.c stm32f10x_it.c
  group Drivers
    ../Drivers/Driver_IO/: stm32f10x_driver_io.c
    ../Drivers/Driver_IIC/: stm32f10x_driver_iic.c
    ../Drivers/Driver_NVIC/: stm32f10x_driver_nvic.c
    ../Drivers/Driver_Timer/: stm32f10x_driver_timer.c
    ../Drivers/Driver_Flash/: stm32f10x_driver_flash.c
    ../Drivers/Driver_USART/: stm32f10x_driver_usart.c
    ../Drivers/Driver_Clock/: stm32f10x_driver_clock.c
    ../Drivers/Driver_Delay/: stm32f10x_driver_delay.c
    ../Drivers/Driver_EEPROM/: stm32f10x_driver_eeprom.c
  group Modules
    ../Modules/Module_LED/: stm32f10x_module_led.c
    ../Modules/Module_Motor/: stm32f10x_module_motor.c
    ../Modules/Module_Battery/: stm32f10x_module_battery.c
    ../Modules/Module_MS5611/: stm32f10x_module_ms5611.c
    ../Modules/Module_MPU6050/: stm32f10x_module_mpu6050.c stm32f10x_module_mpu6050_dmp.c
    ../Modules/Module_HMC5883L/: stm32f10x_module_hmc5883l.c
    ../Modules/Module_CommLink/: stm32f10x_module_comm_link.c
  group Algorithm
    ../Algorithm/Algorithm_IMU/: stm32f10x_algorithm_imu.c
    ../Algorithm/Algorithm_Filter/: stm32f10x_algorithm_filter.c
    ../Algorithm/Algorithm_Flight/: stm32f10x_algorithm_flight.c
    ../Algorithm/Algorithm_Control/: stm32f10x_algorithm_control.c
    ../Algorithm/Algorithm_Altitude/: stm32f10x_algorithm_altitude.c
